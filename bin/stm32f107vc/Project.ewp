# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\config; ..\..\include; ..\..\arch\stm32f1; ..\..\arch\stm32f1\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\arch\stm32f1\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\osek\inc; ..\..\osek\vPort\armv7_m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\osek\vPort\armv7_m
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group app
    ../../app/: app.c
  group arch
    ../../arch/stm32f1/: Compiler.h Platform_Types.h
  group arch/Libraries/CMSIS
    ../../arch/stm32f1/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group arch/Libraries/CMSIS/startup
    ../../arch/stm32f1/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group arch/Libraries/StdPeriph/inc
    ../../arch/stm32f1/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_conf.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_usart.h
  group arch/Libraries/StdPeriph/src
    ../../arch/stm32f1/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group config
    ../../config/: osek_cfg.c osek_cfg.h
  group include
    ../../include/: Os.h Std_Types.h
  group osek/inc
    ../../osek/inc/: knl_alarm.h knl_bitop.h knl_queue.h knl_resource.h knl_task.h longlong.h osek_check.h osek_os.h
  group osek/src
    ../../osek/src/: knl_alarm.c knl_bitop.c knl_misc.c knl_task.c osek_alarm.c osek_counter.c osek_event.c osek_interrupt.c osek_osctrl.c osek_resource.c osek_task.c
  group osek/vPort
    ../../osek/vPort/armv7_m/: vPort.c vPort.h vPortMacro.h
    ../../osek/vPort/armv7_m/icc/: vPortS.S
