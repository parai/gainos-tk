<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\libchip_sam3s4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libchip_sam3s2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\libchip_sam3s1.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>libchip_sam3s1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3s2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3s4</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>libchip_sam3s1</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3s2</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3s4</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>build_all</name>
      <member>
        <project>libchip_sam3s1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3s1</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3s2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3s2</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libchip_sam3s4</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sam3s4</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


